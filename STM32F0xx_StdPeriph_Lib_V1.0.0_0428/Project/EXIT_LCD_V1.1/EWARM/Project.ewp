# IAR project Project.ewp, settings and files
configuration STM320518-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F042x6 ST STM32F042x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX; USE_STM320518_EVAL; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include; ..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F0xx_CPAL_Driver\inc; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM320518_EVAL; ..\EXIT_LCD_V1.1(source code)
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: STM32F0508-EVAL.out
  ILINK.IlinkIcfFile: stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_stm32f0xx.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../EXIT_LCD_V1.1(source code)/: APP_Core.c APP_Main.c APP_Uart.c Cap.c Common.c DataType.c HAL_Mcu.c InitSys.c LCD_Core.c LCD_flash.c LCD_lcdinit.c LCD_touch.c MyMisc.c spi.c SysCheck.c Uart.c UartService.c watchDog.c
