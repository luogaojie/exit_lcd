<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM320518-EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f0xx.c</name>
    </file>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\readme.txt</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Source\Templates\iar\startup_stm32f0xx.s</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\src\stm32f0xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\APP_Core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\APP_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\APP_Uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\Cap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\Common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\DataType.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\HAL_Mcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\InitSys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\LCD_Core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\LCD_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\LCD_lcdinit.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\LCD_touch.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\MyMisc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\SysCheck.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\Uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\UartService.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\EXIT_LCD_V1.1(source code)\watchDog.c</name>
    </file>
  </group>
</project>


